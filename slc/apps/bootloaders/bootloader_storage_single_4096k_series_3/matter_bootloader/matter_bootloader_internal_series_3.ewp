# IAR project matter_bootloader_internal_series_3.ewp, settings and files
configuration Default (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG1P233F256GM48 SiliconLaboratories EFR32MG1P233F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $FILE_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $FILE_DIR$
  OBJCOPY.OOCOutputFile: matter_bootloader_internal_series_3.s37
  ILINK.IlinkOutputFile: matter_bootloader_internal_series_3.out
  group (top)
    ./: matter_bootloader_internal_series_3.ipcf
